# Keil uVision project STM32_F407.uvprojx, settings and files
target STM32_F407 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32_F407 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: .eide\deps;Common;Main;Startup_config;STM32F4_FWLIB;USER;STM32F4_FWLIB\inc;STM32F4_FWLIB\src;USER\LED
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    USER/LED/: led.c
  group STM32F4_FWLIB
    STM32F4_FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c
  group Startup_config
    Startup_config/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group Main
    Main/: main.c stm32f4xx_it.c
  group Common
    Common/: common.c
